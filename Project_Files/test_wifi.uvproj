# Keil uVision project test_wifi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1769 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: test_wifi +hex
  c flags: Optim=1
  c include: ..\Source_Files\Common_Files;..\Source_Files\Data_Process;..\Source_Files\Driver_IncludeFiles;..\Source_Files\Main_Files;..\Source_Files\UART_Driver;..\Source_Files\Wifi_Driver;..\Source_Files\Timer
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ../Source_Files/Driver_IncludeFiles/: system_LPC17xx.c startup_LPC17xx.s
    ../Source_Files/Main_Files/: test_wifi.c
    ../Source_Files/Data_Process/: data.c
    ../Source_Files/UART_Driver/: uart.c
    ../Source_Files/Wifi_Driver/: wifi.c
    ../Source_Files/Timer/: timer.c timer1.c
